options:
  parameters:
    generate_options: qt_gui
    id: AFSK
    output_language: python
  states: {}

blocks:
- name: RX_decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '145895000'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,1,1,2)
    rangeType: int
    start: '-6000'
    step: '1'
    stop: '6000'
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,1,1,2)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: bit_rate * 32
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-4'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-40'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.2'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.5'
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1700'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_and_const_xx_1
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: result.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: '.1'
    mu: '.5'
    omega: sample_rate/RX_decimation/bit_rate
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x00'
  states: {state: bypassed}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: 32*sample_rate
    bbdc: 'True'
    buffer_size: '0x8000'
    filter_source: '''Auto'''
    frequency: int(145895000-sample_rate/4+rx_offset)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: 32*sample_rate
    type: fc32
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1200'
    decim: RX_decimation
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '9600'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '1500'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 10,1
    name: Received, synch constellation
    size: 840-84
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: sample_rate/RX_decimation
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: 9,1
    name: '"Bell 202 demodulated signal"'
    showports: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: sample_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 6,1,1,2
    name: '"RX AFSK baseband signal spectrum"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 7,1,1,2
    name: '"FM demodulated signal"'
    showports: 'True'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 10,2
    label1: ''
    name: '"Signal after timing recovery, @1SPS"'
    size: '1000'
    srate: bit_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 9,2
    label1: ''
    name: '"Bell 202 signal before timing recovery, @4SPS"'
    size: '1000'
    srate: sample_rate/RX_decimation
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: (8,1,1,2)
    label1: ''
    name: '"Received Bell 202 signal after de-emphasis"'
    size: '1000'
    srate: sample_rate/RX_decimation
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 7,1,1,2
    label1: ''
    label2: ''
    name: '"Received Bell 202 signal after de-emphasis"'
    size: '200'
    srate: sample_rate/RX_decimation
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (12,1,1,2)
    label1: ''
    name: '"Bits after Descrambler"'
    size: '500'
    srate: bit_rate
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_1_1_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (11,1,1,2)
    label1: ''
    name: '"Bits before decoder"'
    size: '500'
    srate: bit_rate
    type: float
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      This resampler is to decrease the sampling frequency
       because Pluto
       does not accept 38.4kHz
    decim: '50'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rx_offset
  id: parameter
  parameters:
    label: rx_offset
    type: intx
    value: '6600'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.74227'
    type: float
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: 'True'
    bandwidth: 32*sample_rate
    center_freq: int(145895000-sample_rate/4+rx_offset)
    samp_rate: 32*sample_rate
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: int(145895000-sample_rate/4)-freq_offset
    gain: gain
    samp_rate: '1920000.000000'
    type: fc32
  states: {}
- name: tx_offset
  id: parameter
  parameters:
    label: tx_offset
    type: intx
    value: '6500'
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    value: '''ip:192.168.2.1'''
  states: {}

connections:
- [analog_agc3_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_agc3_xx_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [analog_agc3_xx_0, '0', qtgui_time_sink_x_0_0_1_0_0_0, '0']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [analog_pwr_squelch_xx_0, '0', rational_resampler_xxx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_and_const_xx_1, '0', blocks_char_to_float_0_0, '0']
- [blocks_and_const_xx_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_1_1, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_1_1_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_multiply_xx_1_0, '0']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_0_0, '0']
- [blocks_not_xx_0_0, '0', blocks_and_const_xx_1, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_descrambler_bb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_complex_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [digital_descrambler_bb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_not_xx_0_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', single_pole_iir_filter_xx_0, '0']
- [low_pass_filter_0_1, '0', analog_agc3_xx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [rational_resampler_xxx_1_0, '0', low_pass_filter_0_1, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_float_to_complex_0_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_time_sink_x_0_0_1_0_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_pwr_squelch_xx_0, '0']

metadata:
  file_format: 1
